FILESEXTRAPATHS:prepend:versal-2ve-2vm := "${THISDIR}/files:"
SRC_URI:append:versal-2ve-2vm = " file://0001-remoteproc-xlnx-introduce-new-fw-elf-loader.patch\
				  file://0001-drm-xlnx-hdmi-add-support-for-hotplug-in-TMDS-mode.patch "
