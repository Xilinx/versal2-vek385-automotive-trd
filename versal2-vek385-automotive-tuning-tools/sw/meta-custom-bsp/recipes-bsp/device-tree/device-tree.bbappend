FILESEXTRAPATHS:prepend:versal-2ve-2vm-vek385-revb-multidomain:linux := "${THISDIR}/files:"
EXTRA_DT_INCLUDE_FILES:append:versal-2ve-2vm-vek385-revb-multidomain:linux = " system_user.dtsi"
