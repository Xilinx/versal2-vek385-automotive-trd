FILESEXTRAPATHS:prepend:versal-2ve-2vm := "${THISDIR}/files:"
SRC_URI:append:versal-2ve-2vm = " file://0001-visp_video-reduce-min_queued_buffers-from-5-to-3-for.patch"
